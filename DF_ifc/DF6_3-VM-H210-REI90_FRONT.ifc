Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:33:00
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/3-VM-H210-REI90
CADClick-Properties - Bestellnummer: 1017952; Beschreibung: DF6/3-VM-H210-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DF6/3-VM-H210-REI90; EAN: 4024342496815; Name: DF6/3-VM-H210-REI90
