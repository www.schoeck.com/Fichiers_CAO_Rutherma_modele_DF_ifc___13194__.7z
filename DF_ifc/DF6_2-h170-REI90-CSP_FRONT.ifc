Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:49:36
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/2-h170-REI90-CSP
CADClick-Properties - Bestellnummer: 1029228; Beschreibung: DF6/2-h170-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/2-h170-REI90-CSP; EAN: 4024342532728; Name: DF6/2-h170-REI90-CSP
