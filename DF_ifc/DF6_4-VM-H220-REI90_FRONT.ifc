Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:45:38
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/4-VM-H220-REI90
CADClick-Properties - Bestellnummer: 1017961; Beschreibung: DF6/4-VM-H220-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DF6/4-VM-H220-REI90; EAN: 4024342496907; Name: DF6/4-VM-H220-REI90
