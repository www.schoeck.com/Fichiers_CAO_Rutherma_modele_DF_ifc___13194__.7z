Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T00:24:57
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/10-h190-REI90
CADClick-Properties - Bestellnummer: 193100; Beschreibung: DF6/10-h190-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DF6/10-h190-REI90; EAN: 4024342328918; Name: DF6/10-h190-REI90
