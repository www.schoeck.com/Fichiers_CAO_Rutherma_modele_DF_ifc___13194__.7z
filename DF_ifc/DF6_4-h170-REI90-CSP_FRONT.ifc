Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T00:27:45
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/4-h170-REI90-CSP
CADClick-Properties - Bestellnummer: 193056; Beschreibung: DF6/4-h170-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/4-h170-REI90-CSP; EAN: 4024342329182; Name: DF6/4-h170-REI90-CSP
