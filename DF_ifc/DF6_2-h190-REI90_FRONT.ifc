Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T00:07:12
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/2-h190-REI90
CADClick-Properties - Bestellnummer: 173469; Beschreibung: DF6/2-h190-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DF6/2-h190-REI90; EAN: 4024342395538; Name: DF6/2-h190-REI90
