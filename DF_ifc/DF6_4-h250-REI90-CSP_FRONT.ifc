Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T00:25:15
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/4-h250-REI90-CSP
CADClick-Properties - Bestellnummer: 181629; Beschreibung: DF6/4-h250-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/4-h250-REI90-CSP; EAN: 4024342369171; Name: DF6/4-h250-REI90-CSP
