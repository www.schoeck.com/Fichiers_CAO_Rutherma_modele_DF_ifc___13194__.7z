Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T00:16:25
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/4-h200-REI90-CSP
CADClick-Properties - Bestellnummer: 161052; Beschreibung: DF6/4-h200-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/4-h200-REI90-CSP; EAN: 4024342404940; Name: DF6/4-h200-REI90-CSP
