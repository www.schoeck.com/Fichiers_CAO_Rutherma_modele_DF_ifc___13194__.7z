Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T00:12:04
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/2-h250-REI90
CADClick-Properties - Bestellnummer: 166388; Beschreibung: DF6/2-h250-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DF6/2-h250-REI90; EAN: 4024342400812; Name: DF6/2-h250-REI90
