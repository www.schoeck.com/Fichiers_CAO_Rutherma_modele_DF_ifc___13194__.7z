Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:39:55
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/7-VM-H230-REI90-CSP
CADClick-Properties - Bestellnummer: 1017928; Beschreibung: DF6/7-VM-H230-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/7-VM-H230-REI90-CSP; EAN: 4024342496570; Name: DF6/7-VM-H230-REI90-CSP
