Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:40:26
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/5-VM-H200-REI90
CADClick-Properties - Bestellnummer: 1017967; Beschreibung: DF6/5-VM-H200-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DF6/5-VM-H200-REI90; EAN: 4024342496969; Name: DF6/5-VM-H200-REI90
