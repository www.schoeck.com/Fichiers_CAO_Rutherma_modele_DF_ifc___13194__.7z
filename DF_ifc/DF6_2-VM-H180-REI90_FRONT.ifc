Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:40:09
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/2-VM-H180-REI90
CADClick-Properties - Bestellnummer: 1017941; Beschreibung: DF6/2-VM-H180-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DF6/2-VM-H180-REI90; EAN: 4024342496709; Name: DF6/2-VM-H180-REI90
