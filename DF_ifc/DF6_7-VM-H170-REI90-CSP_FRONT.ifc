Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:47:03
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/7-VM-H170-REI90-CSP
CADClick-Properties - Bestellnummer: 1017922; Beschreibung: DF6/7-VM-H170-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/7-VM-H170-REI90-CSP; EAN: 4024342496518; Name: DF6/7-VM-H170-REI90-CSP
