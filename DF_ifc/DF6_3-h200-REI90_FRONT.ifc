Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:57:58
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/3-h200-REI90
CADClick-Properties - Bestellnummer: 138194; Beschreibung: DF6/3-h200-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DF6/3-h200-REI90; EAN: 4024342283989; Name: DF6/3-h200-REI90
