Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:44:15
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/10-VM-H230-REI90-CSP
CADClick-Properties - Bestellnummer: 1017938; Beschreibung: DF6/10-VM-H230-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/10-VM-H230-REI90-CSP; EAN: 4024342496679; Name: DF6/10-VM-H230-REI90-CSP
