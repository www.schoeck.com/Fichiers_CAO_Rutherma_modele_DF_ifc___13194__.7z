Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T00:17:36
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/10-h200-REI90-CSP
CADClick-Properties - Bestellnummer: 164643; Beschreibung: DF6/10-h200-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/10-h200-REI90-CSP; EAN: 4024342402045; Name: DF6/10-h200-REI90-CSP
