Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:15:14
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DF6/2-VM-H210-REI90-CSP
CADClick-Properties - Bestellnummer: 1017886; Beschreibung: DF6/2-VM-H210-REI90-CSP; Hersteller: Schöck Bauteile GmbH; Datei: DF6/2-VM-H210-REI90-CSP; EAN: 4024342496150; Name: DF6/2-VM-H210-REI90-CSP
